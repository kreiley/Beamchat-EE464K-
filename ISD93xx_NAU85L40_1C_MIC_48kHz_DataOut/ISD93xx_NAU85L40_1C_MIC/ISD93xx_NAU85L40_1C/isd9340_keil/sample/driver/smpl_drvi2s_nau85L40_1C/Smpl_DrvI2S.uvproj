# Keil uVision project Smpl_DrvI2S.uvproj, settings and files
target Smpl_DrvI2S (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: ISD9360 Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x233FF) CLOCK(49152000) CPUTYPE("Cortex-M0")
  output: Smpl_DrvI2S
  AfterMake: fromelf --bin ".\obj\@L.axf" --output "..\..\..\..\binfiles\@L.bin"
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: nSEMIHOST
  c include: .\;..\..\..\..\HW;..\..\..\..\CMSIS\CM0\CoreSupport;..\..\..\..\CMSIS\CM0\DeviceSupport\Nuvoton\ISD93xx;..\..\..\Include;..\..\..\Include\Driver
  memory RVCT4: ROM 0x0 size 0x23400
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='boot_ISD93xx.o(vectors)' --datacompressor=off --info=inline --entry Reset_Handler --callgraph
  group CMSIS files
    ../../../../CMSIS/CM0/CoreSupport/: core_cm0.c
    ../../../../CMSIS/CM0/DeviceSupport/Nuvoton/ISD93xx/: boot_ISD93xx.c system_ISD93xx.c
  group Source files
    ./: Smpl_DrvI2S.c NAU85L40Setup.c
  group Library files
    ../../../Src/Driver/: retarget.c DrvI2C.c DrvI2S.c DrvGPIO.c DrvSYS.c DrvUART.c DrvDPWM.c DrvPDMA.c
    ../../../Lib/: SemiHost_Keil.lib
